# Keil uVision project ESP8266-4.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: ESP8266-1 +hex
  c flags: Optimize=8 SizeSpeed=1
  group SourceFiles
    ./USER/: main.c esp8266.c uart.c ds18b20.c delay.c
  group IncludeFiles
    ./USER/: config.h delay.h ds18b20.h esp8266.h uart.h
